# Keil uVision project IlyaRelay.uvproj, settings and files
target IlyaRelay (MCS-51)
  device: STC15W204S Series STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: IlyaRelay +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\IlyaRelay
  group Source
    ./: STARTUP.A51 main.c
